File: G2/Status.sch (KiCad schematic (older format))
At the start: 47 parts, among them J601 Conn_02x08_Odd_Even, U601 TXB0102DCU

Commit message: Fixed backwards connected TXB0102DCUs. Fixed rgb led ctrl being connected instead of level shift enable to TXB0102DCU. Made the hole for IRD contact larger. Increased hole size for screw terminals
Connections:
- net +3V3_S: now also U601.3 (VCCA); no longer U601.7 (VCCB)
- net +5V_S: now also U601.7 (VCCB); no longer U601.3 (VCCA)
- net RGB_LED_DATA_CTRL: now also U601.5 (A1); no longer U601.8 (B1)
- net at LED601.4 (DIN): now also U601.8 (B1); no longer U601.5 (A1)
Other:
- moved on the sheet: C601, C602
Changed lines of the file:
@@
 F 3 "" H 2050 1570 50  0001 C CNN
 	1    2050 1600
-	-1   0    0    -1
+	1    0    0    1
 $EndComp
 $Comp
 L C C602
 U 1 1 59CCDAC7
-P 2500 1050
-F 0 "C602" V 2248 1050 50  0000 C CNN
-F 1 "100n" V 2339 1050 50  0000 C CNN
-F 2 "Capacitors_SMD:C_0805" H 2538 900 50  0001 C CNN
-F 3 "" H 2500 1050 50  0001 C CNN
-	1    2500 1050
-	0    -1   1    0
+P 2150 2250
+F 0 "C602" V 1898 2250 50  0000 C CNN
+F 1 "100n" V 1989 2250 50  0000 C CNN
+F 2 "Capacitors_SMD:C_0805" H 2188 2100 50  0001 C CNN
+F 3 "" H 2150 2250 50  0001 C CNN
+	1    2150 2250
+	-1   0    0    -1
 $EndComp
 $Comp
 L C C601
 U 1 1 59CCDACE
-P 1700 1050
-F 0 "C601" V 1448 1050 50  0000 C CNN
-F 1 "100n" V 1539 1050 50  0000 C CNN
-F 2 "Capacitors_SMD:C_0805" H 1738 900 50  0001 C CNN
-F 3 "" H 1700 1050 50  0001 C CNN
-	1    1700 1050
-	0    -1   1    0
-$EndComp
-NoConn ~ 2450 1700
+P 1950 2250
+F 0 "C601" V 1698 2250 50  0000 C CNN
+F 1 "100n" V 1789 2250 50  0000 C CNN
+F 2 "Capacitors_SMD:C_0805" H 1988 2100 50  0001 C CNN
+F 3 "" H 1950 2250 50  0001 C CNN
+	1    1950 2250
+	1    0    0    1
+$EndComp
 Text Label 3800 2950 0    60   ~ 0
 RGB_LED_DATA_CTRL
-Text Label 3800 1900 0    60   ~ 0
+Text Label 3800 2850 0    60   ~ 0
 LEVEL_SHIFTER_ENABLE
 Text Notes 2160 5500 3    60   ~ 0
@@
 L +5V_S #PWR0137
 U 1 1 59CAF39F
-P 2150 1000
-F 0 "#PWR0137" H 2150 850 50  0001 C CNN
-F 1 "+5V_S" V 2150 1250 50  0000 C CNN
-F 2 "" H 2150 1000 50  0001 C CNN
-F 3 "" H 2150 1000 50  0001 C CNN
-	1    2150 1000
-	1    0    0    -1
+P 2150 2100
+F 0 "#PWR0137" H 2150 1950 50  0001 C CNN
+F 1 "+5V_S" V 2150 2350 50  0000 C CNN
+F 2 "" H 2150 2100 50  0001 C CNN
+F 3 "" H 2150 2100 50  0001 C CNN
+	1    2150 2100
+	0    1    1    0
 $EndComp
 $Comp
 L +3V3_S #PWR0138
 U 1 1 59CAF727
-P 1950 1000
-F 0 "#PWR0138" H 1950 850 50  0001 C CNN
-F 1 "+3V3_S" V 1950 1250 50  0000 C CNN
-F 2 "" H 1950 1000 50  0001 C CNN
-F 3 "" H 1950 1000 50  0001 C CNN
-	1    1950 1000
-	1    0    0    -1
+P 1950 2100
+F 0 "#PWR0138" H 1950 1950 50  0001 C CNN
+F 1 "+3V3_S" V 1950 2350 50  0000 C CNN
+F 2 "" H 1950 2100 50  0001 C CNN
+F 3 "" H 1950 2100 50  0001 C CNN
+	1    1950 2100
+	0    -1   -1   0
 $EndComp
 $Comp
 L GND_S #PWR0139
 U 1 1 59CB0145
-P 1550 1050
-F 0 "#PWR0139" H 1550 800 50  0001 C CNN
-F 1 "GND_S" V 1555 922 50  0000 R CNN
-F 2 "" H 1550 1050 50  0001 C CNN
-F 3 "" H 1550 1050 50  0001 C CNN
-	1    1550 1050
-	0    1    1    0
+P 1950 2400
+F 0 "#PWR0139" H 1950 2150 50  0001 C CNN
+F 1 "GND_S" V 1955 2272 50  0000 R CNN
+F 2 "" H 1950 2400 50  0001 C CNN
+F 3 "" H 1950 2400 50  0001 C CNN
+	1    1950 2400
+	1    0    0    -1
 $EndComp
 $Comp
 L GND_S #PWR0140
 U 1 1 59CB0625
-P 2650 1050
-F 0 "#PWR0140" H 2650 800 50  0001 C CNN
-F 1 "GND_S" V 2655 922 50  0000 R CNN
-F 2 "" H 2650 1050 50  0001 C CNN
-F 3 "" H 2650 1050 50  0001 C CNN
-	1    2650 1050
-	0    -1   -1   0
+P 2150 2400
+F 0 "#PWR0140" H 2150 2150 50  0001 C CNN
+F 1 "GND_S" V 2155 2272 50  0000 R CNN
+F 2 "" H 2150 2400 50  0001 C CNN
+F 3 "" H 2150 2400 50  0001 C CNN
+	1    2150 2400
+	1    0    0    -1
 $EndComp
 $Comp
@@
 L GND_S #PWR0127
 U 1 1 59CB54ED
-P 2050 2100
-F 0 "#PWR0127" H 2050 1850 50  0001 C CNN
-F 1 "GND_S" H 2055 1927 50  0000 C CNN
-F 2 "" H 2050 2100 50  0001 C CNN
-F 3 "" H 2050 2100 50  0001 C CNN
-	1    2050 2100
-	1    0    0    -1
+P 2050 1100
+F 0 "#PWR0127" H 2050 850 50  0001 C CNN
+F 1 "GND_S" H 2055 927 50  0000 C CNN
+F 2 "" H 2050 1100 50  0001 C CNN
+F 3 "" H 2050 1100 50  0001 C CNN
+	1    2050 1100
+	-1   0    0    1
 $EndComp
 $Comp
@@
 	1500 6750 1500 6700
 Wire Wire Line
-	2150 1000 2150 1100
-Wire Wire Line
-	2350 1050 2150 1050
-Connection ~ 2150 1050
-Wire Wire Line
-	1950 1000 1950 1100
-Wire Wire Line
-	1950 1050 1850 1050
-Connection ~ 1950 1050
-Wire Wire Line
-	2450 1500 3200 1500
-Wire Wire Line
 	2600 4450 2600 5000
 Wire Wire Line
@@
 Wire Wire Line
 	3650 5550 3650 6400
-Wire Wire Line
-	1650 1500 1250 1500
-Wire Wire Line
-	1250 1500 1250 2950
 Wire Notes Line
 	1150 3250 1150 4900
@@
 Wire Wire Line
 	2750 6200 2750 6400
-Wire Wire Line
-	1250 2950 5350 2950
-Wire Wire Line
-	5350 2850 4850 2850
-Wire Wire Line
-	4850 2850 4850 1900
-Wire Wire Line
-	4850 1900 2450 1900
 NoConn ~ 9000 1400
 $Comp
@@
 	1    0    0    -1
 $EndComp
-NoConn ~ 1650 1700
 $Comp
 L PogoPins02x06_Pitch5.08_ContactSurface PG601
@@
 	1    0    0    -1
 $EndComp
+Wire Wire Line
+	3200 1500 3200 1700
+Wire Wire Line
+	3200 1700 2450 1700
+NoConn ~ 2450 1500
+NoConn ~ 1650 1500
+Wire Wire Line
+	5350 2850 1400 2850
+Wire Wire Line
+	1400 2850 1400 1300
+Wire Wire Line
+	1400 1300 1650 1300
+Wire Wire Line
+	5350 2950 1550 2950
+Wire Wire Line
+	1550 2950 1550 1700
+Wire Wire Line
+	1550 1700 1650 1700
 $EndSCHEMATC

Commit message: No longer uses Pogo pins
Parts:
- removed PG601: PogoPins02x06_Pitch5.08_ContactSurface, PogoPins02x06_Pitch5:PogoPins02x06_Pitch5.08_ContactSurface, symbol PogoPins02x06_Pitch5.08_ContactSurface
- added J602: Conn_01x08, LocalComponents:WE68710814022_8x0.50mm_SMT_ZIF_Horizontal_Top, symbol Conn_01x08
Connections:
- net +3V3_S: now also J602.5 (Pin_5), J602.6 (Pin_6)
- net +5V_S: now also J602.3 (Pin_3), J602.4 (Pin_4)
- net GND_S: now also J602.1 (Pin_1), J602.2 (Pin_2)
- net LEVEL_SHIFTER_ENABLE: now also J602.7 (Pin_7)
- net RGB_LED_DATA_CTRL: now also J602.8 (Pin_8)
Changed lines of the file:
@@
 L +3V3_S #PWR0130
 U 1 1 59CAE1C1
-P 6000 2450
-F 0 "#PWR0130" H 6000 2300 50  0001 C CNN
-F 1 "+3V3_S" V 6000 2600 50  0000 L CNN
-F 2 "" H 6000 2450 50  0001 C CNN
-F 3 "" H 6000 2450 50  0001 C CNN
-	1    6000 2450
-	0    1    1    0
+P 5350 2750
+F 0 "#PWR0130" H 5350 2600 50  0001 C CNN
+F 1 "+3V3_S" V 5350 2900 50  0000 L CNN
+F 2 "" H 5350 2750 50  0001 C CNN
+F 3 "" H 5350 2750 50  0001 C CNN
+	1    5350 2750
+	0    -1   -1   0
 $EndComp
 $Comp
 L GND_S #PWR0131
 U 1 1 59CAE2F4
+P 5350 2250
+F 0 "#PWR0131" H 5350 2000 50  0001 C CNN
+F 1 "GND_S" V 5355 2122 50  0000 R CNN
+F 2 "" H 5350 2250 50  0001 C CNN
+F 3 "" H 5350 2250 50  0001 C CNN
+	1    5350 2250
+	0    1    1    0
+$EndComp
+$Comp
+L +3V3_S #PWR0132
+U 1 1 59CAE368
+P 5350 2650
+F 0 "#PWR0132" H 5350 2500 50  0001 C CNN
+F 1 "+3V3_S" V 5350 2800 50  0000 L CNN
+F 2 "" H 5350 2650 50  0001 C CNN
+F 3 "" H 5350 2650 50  0001 C CNN
+	1    5350 2650
+	0    -1   -1   0
+$EndComp
+$Comp
+L GND_S #PWR0133
+U 1 1 59CAE815
+P 5350 2350
+F 0 "#PWR0133" H 5350 2100 50  0001 C CNN
+F 1 "GND_S" V 5355 2222 50  0000 R CNN
+F 2 "" H 5350 2350 50  0001 C CNN
+F 3 "" H 5350 2350 50  0001 C CNN
+	1    5350 2350
+	0    1    1    0
+$EndComp
+$Comp
+L +5V_S #PWR0134
+U 1 1 59CAED7D
 P 5350 2450
-F 0 "#PWR0131" H 5350 2200 50  0001 C CNN
-F 1 "GND_S" V 5355 2322 50  0000 R CNN
+F 0 "#PWR0134" H 5350 2300 50  0001 C CNN
+F 1 "+5V_S" V 5365 2578 50  0000 L CNN
 F 2 "" H 5350 2450 50  0001 C CNN
 F 3 "" H 5350 2450 50  0001 C CNN
 	1    5350 2450
-	0    1    1    0
-$EndComp
-$Comp
-L +3V3_S #PWR0132
-U 1 1 59CAE368
-P 6000 2550
-F 0 "#PWR0132" H 6000 2400 50  0001 C CNN
-F 1 "+3V3_S" V 6000 2700 50  0000 L CNN
-F 2 "" H 6000 2550 50  0001 C CNN
-F 3 "" H 6000 2550 50  0001 C CNN
-	1    6000 2550
-	0    1    1    0
-$EndComp
-$Comp
-L GND_S #PWR0133
-U 1 1 59CAE815
+	0    -1   -1   0
+$EndComp
+$Comp
+L +5V_S #PWR0135
+U 1 1 59CAEEB5
 P 5350 2550
-F 0 "#PWR0133" H 5350 2300 50  0001 C CNN
-F 1 "GND_S" V 5355 2422 50  0000 R CNN
+F 0 "#PWR0135" H 5350 2400 50  0001 C CNN
+F 1 "+5V_S" V 5365 2678 50  0000 L CNN
 F 2 "" H 5350 2550 50  0001 C CNN
 F 3 "" H 5350 2550 50  0001 C CNN
 	1    5350 2550
-	0    1    1    0
-$EndComp
-$Comp
-L +5V_S #PWR0134
-U 1 1 59CAED7D
-P 5350 2650
-F 0 "#PWR0134" H 5350 2500 50  0001 C CNN
-F 1 "+5V_S" V 5365 2778 50  0000 L CNN
-F 2 "" H 5350 2650 50  0001 C CNN
-F 3 "" H 5350 2650 50  0001 C CNN
-	1    5350 2650
-	0    -1   -1   0
-$EndComp
-$Comp
-L +5V_S #PWR0135
-U 1 1 59CAEEB5
-P 5350 2750
-F 0 "#PWR0135" H 5350 2600 50  0001 C CNN
-F 1 "+5V_S" V 5365 2878 50  0000 L CNN
-F 2 "" H 5350 2750 50  0001 C CNN
-F 3 "" H 5350 2750 50  0001 C CNN
-	1    5350 2750
 	0    -1   -1   0
 $EndComp
@@
 	1    0    0    -1
 $EndComp
-Text Notes 5500 3100 0    60   ~ 0
+Text Notes 5400 3100 0    60   ~ 0
 To MCU
 Wire Wire Line
@@
 	1    0    0    -1
 $EndComp
-$Comp
-L PogoPins02x06_Pitch5.08_ContactSurface PG601
-U 1 1 59CF7341
-P 5550 2350
-F 0 "PG601" H 5675 2497 60  0000 C CNN
-F 1 "PogoPins02x06_Pitch5.08_ContactSurface" H 5675 2391 60  0000 C CNN
-F 2 "PogoPins02x06_Pitch5:PogoPins02x06_Pitch5.08_ContactSurface" H 5550 2350 60  0001 C CNN
-F 3 "" H 5550 2350 60  0001 C CNN
-	1    5550 2350
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	3200 1500 3200 1700
@@
 Wire Wire Line
 	1550 1700 1650 1700
+$Comp
+L Conn_01x08 J602
+U 1 1 5A080018
+P 5550 2550
+F 0 "J602" H 5630 2542 50  0000 L CNN
+F 1 "Conn_01x08" H 5630 2451 50  0000 L CNN
+F 2 "LocalComponents:WE68710814022_8x0.50mm_SMT_ZIF_Horizontal_Top" H 5550 2550 50  0001 C CNN
+F 3 "https://www.mouser.se/Search/ProductDetail.aspx?qs=ZtY9WdtwX54hJHBraEAPJw%3d%3d" H 5550 2550 50  0001 C CNN
+	1    5550 2550
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC
