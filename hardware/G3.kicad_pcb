# Repository PerMalmberg/IO-Card-G3 (continued)

## KiCad design hardware/G3.kicad_pcb (continued)

Parts:
C601: 100n; C_0805_2012Metric
D601: CDBA3100-HF; D_SMA
D602, D603: STPS0560Z; D_SOD-123
R601: 1k; R_0805_2012Metric
R602: 2k; R_0805_2012Metric
R603: 100; R_0805_2012Metric
RV601: B72510E250K062; C_0805_2012Metric

Connections:
+5V: D602.1 (K), R602.1; also elsewhere on the board
/AnalogInput/AnalogSensCircuit1/Adc: R603.2; also elsewhere on the board
GND: C601.2, D601.2 (A), D603.2 (A), RV601.1; also elsewhere on the board
unnamed: C601.1, D602.2 (A), D603.1 (K), R601.2, R602.2, R603.1
Sense1_DUT: D601.1 (K), R601.1, RV601.2; also elsewhere on the board

Parts of its further copies:
C701, C801, C901, C1001, C1101, C1201, C1301: 100n; C_0805_2012Metric
D701, D801, D901, D1001, D1101, D1201, D1301: CDBA3100-HF; D_SMA
D702, D703, D802, D803, D902, D903, D1002, D1003, D1102, D1103, D1202, D1203, D1302, D1303: STPS0560Z; D_SOD-123
R701, R801, R901, R1001, R1101, R1201, R1301: 1k; R_0805_2012Metric
R702, R802, R902, R1002, R1102, R1202, R1302: 2k; R_0805_2012Metric
R703, R803, R903, R1003, R1103, R1203, R1303: 100; R_0805_2012Metric
RV701, RV801, RV901, RV1001, RV1101, RV1201, RV1301: B72510E250K062; C_0805_2012Metric

Connections of its further copies:
+5V: D702.1 (K), D802.1 (K), D902.1 (K), D1002.1 (K), D1102.1 (K), D1202.1 (K), D1302.1 (K), R702.1, R802.1, R902.1, R1002.1, R1102.1, R1202.1, R1302.1; also elsewhere on the board
/AnalogInput/AnalogSensCircuit2/Adc: R703.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit3/Adc: R803.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit4/Adc: R903.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit5/Adc: R1003.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit6/Adc: R1103.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit7/Adc: R1203.2; also elsewhere on the board
/AnalogInput/AnalogSensCircuit8/Adc: R1303.2; also elsewhere on the board
GND: C701.2, C801.2, C901.2, C1001.2, C1101.2, C1201.2, C1301.2, D701.2 (A), D703.2 (A), D801.2 (A), D803.2 (A), D901.2 (A), D903.2 (A), D1001.2 (A), D1003.2 (A), D1101.2 (A), D1103.2 (A), D1201.2 (A), D1203.2 (A), D1301.2 (A), D1303.2 (A), RV701.1, RV801.1, RV901.1, RV1001.1, RV1101.1, RV1201.1, RV1301.1; also elsewhere on the board
unnamed: C701.1, D702.2 (A), D703.1 (K), R701.2, R702.2, R703.1
unnamed: C801.1, D802.2 (A), D803.1 (K), R801.2, R802.2, R803.1
unnamed: C901.1, D902.2 (A), D903.1 (K), R901.2, R902.2, R903.1
unnamed: C1001.1, D1002.2 (A), D1003.1 (K), R1001.2, R1002.2, R1003.1
unnamed: C1101.1, D1102.2 (A), D1103.1 (K), R1101.2, R1102.2, R1103.1
unnamed: C1201.1, D1202.2 (A), D1203.1 (K), R1201.2, R1202.2, R1203.1
unnamed: C1301.1, D1302.2 (A), D1303.1 (K), R1301.2, R1302.2, R1303.1
Sense2_DUT: D701.1 (K), R701.1, RV701.2; also elsewhere on the board
Sense3_DUT: D801.1 (K), R801.1, RV801.2; also elsewhere on the board
Sense4_DUT: D901.1 (K), R901.1, RV901.2; also elsewhere on the board
Sense5_DUT: D1001.1 (K), R1001.1, RV1001.2; also elsewhere on the board
Sense6_DUT: D1101.1 (K), R1101.1, RV1101.2; also elsewhere on the board
Sense7_DUT: D1201.1 (K), R1201.1, RV1201.2; also elsewhere on the board
Sense8_DUT: D1301.1 (K), R1301.1, RV1301.2; also elsewhere on the board

Schematic: DigitalInput.sch

Parts:
C1501: 10u; CP_Elec_5x4.5
D1501: Red; LED_D5.0mm
F1501: xA; Fuseholder_TR5_Littlefuse_No560_No460
J1501: Digital input supply; PinHeader_1x03_P2.54mm_Vertical
J1502: Digital input GND; PinHeader_1x02_P2.54mm_Vertical
R1501: 1k; R_2512_6332Metric
R1502: 1.65k; R_0805_2012Metric
R1503: 100; R_0805_2012Metric
R1504: 10k; R_0805_2012Metric
U1501: LTV-354T; SO-4_4.4x3.6mm_P2.54mm

Connections:
12V_PWR: J1501.1; also elsewhere on the board
+5V: J1501.3; also elsewhere on the board
/DigitalIO/DigitalInput1/DI_in1: R1501.1, U1501.1
DI1: D1501.1 (K), R1503.1, R1504.2, U1501.4; also elsewhere on the board
DI1_1: R1501.2; also elsewhere on the board
DI1_2: J1502.1, U1501.2; also elsewhere on the board
DI1_PWR: F1501.1; also elsewhere on the board
GND: C1501.2, J1502.2, U1501.3; also elsewhere on the board
unnamed: C1501.1, R1503.2
unnamed: D1501.2 (A), R1502.1
unnamed: F1501.2, J1501.2

Parts of its further copies:
C2801, C2901, C3001, C3101, C3201, C3301, C3401: 10u; CP_Elec_5x4.5
D2801, D2901, D3001, D3101, D3201, D3301, D3401: Red; LED_D5.0mm
F2801, F2901, F3001, F3101, F3201, F3301, F3401: xA; Fuseholder_TR5_Littlefuse_No560_No460
J2801, J2901, J3001, J3101, J3201, J3301, J3401: Digital input supply; PinHeader_1x03_P2.54mm_Vertical
J2802, J2902, J3002, J3102, J3202, J3302, J3402: Digital input GND; PinHeader_1x02_P2.54mm_Vertical
R2801, R2901, R3001, R3101, R3201, R3301, R3401: 1k; R_2512_6332Metric
R2802, R2902, R3002, R3102, R3202, R3302, R3402: 1.65k; R_0805_2012Metric
R2803, R2903, R3003, R3103, R3203, R3303, R3403: 100; R_0805_2012Metric
R2804, R2904, R3004, R3104, R3204, R3304, R3404: 10k; R_0805_2012Metric
U2801, U2901, U3001, U3101, U3201, U3301, U3401: LTV-354T; SO-4_4.4x3.6mm_P2.54mm

Connections of its further copies:
12V_PWR: J2801.1, J2901.1, J3001.1, J3101.1, J3201.1, J3301.1, J3401.1; also elsewhere on the board
+5V: J2801.3, J2901.3, J3001.3, J3101.3, J3201.3, J3301.3, J3401.3; also elsewhere on the board
/DigitalIO/DigitalInput2/DI_in1: R2801.1, U2801.1
/DigitalIO/DigitalInput3/DI_in1: R2901.1, U2901.1
/DigitalIO/DigitalInput4/DI_in1: R3001.1, U3001.1
/DigitalIO/DigitalInput5/DI_in1: R3101.1, U3101.1
/DigitalIO/DigitalInput6/DI_in1: R3201.1, U3201.1
/DigitalIO/DigitalInput7/DI_in1: R3301.1, U3301.1
/DigitalIO/DigitalInput8/DI_in1: R3401.1, U3401.1
DI2: D2801.1 (K), R2803.1, R2804.2, U2801.4; also elsewhere on the board
DI2_1: R2801.2; also elsewhere on the board
DI2_2: J2802.1, U2801.2; also elsewhere on the board
DI2_PWR: F2801.1; also elsewhere on the board
DI3: D2901.1 (K), R2903.1, R2904.2, U2901.4; also elsewhere on the board
DI3_1: R2901.2; also elsewhere on the board
DI3_2: J2902.1, U2901.2; also elsewhere on the board
DI3_PWR: F2901.1; also elsewhere on the board
DI4: D3001.1 (K), R3003.1, R3004.2, U3001.4; also elsewhere on the board
DI4_1: R3001.2; also elsewhere on the board
DI4_2: J3002.1, U3001.2; also elsewhere on the board
DI4_PWR: F3001.1; also elsewhere on the board
DI5: D3101.1 (K), R3103.1, R3104.2, U3101.4; also elsewhere on the board
DI5_1: R3101.2; also elsewhere on the board
DI5_2: J3102.1, U3101.2; also elsewhere on the board
DI5_PWR: F3101.1; also elsewhere on the board
DI6: D3201.1 (K), R3203.1, R3204.2, U3201.4; also elsewhere on the board
DI6_1: R3201.2; also elsewhere on the board
DI6_2: J3202.1, U3201.2; also elsewhere on the board
DI6_PWR: F3201.1; also elsewhere on the board
DI7: D3301.1 (K), R3303.1, R3304.2, U3301.4; also elsewhere on the board
DI7_1: R3301.2; also elsewhere on the board
DI7_2: J3302.1, U3301.2; also elsewhere on the board
DI7_PWR: F3301.1; also elsewhere on the board
DI8: D3401.1 (K), R3403.1, R3404.2, U3401.4; also elsewhere on the board
DI8_1: R3401.2; also elsewhere on the board
DI8_2: J3402.1, U3401.2; also elsewhere on the board
DI8_PWR: F3401.1; also elsewhere on the board
GND: C2801.2, C2901.2, C3001.2, C3101.2, C3201.2, C3301.2, C3401.2, J2802.2, J2902.2, J3002.2, J3102.2, J3202.2, J3302.2, J3402.2, U2801.3, U2901.3, U3001.3, U3101.3, U3201.3, U3301.3, U3401.3; also elsewhere on the board
unnamed: C2801.1, R2803.2
unnamed: C2901.1, R2903.2
unnamed: C3001.1, R3003.2
unnamed: C3101.1, R3103.2
unnamed: C3201.1, R3203.2
unnamed: C3301.1, R3303.2
unnamed: C3401.1, R3403.2
unnamed: D2801.2 (A), R2802.1
unnamed: D2901.2 (A), R2902.1
unnamed: D3001.2 (A), R3002.1
unnamed: D3101.2 (A), R3102.1
unnamed: D3201.2 (A), R3202.1
unnamed: D3301.2 (A), R3302.1
unnamed: D3401.2 (A), R3402.1
unnamed: F2801.2, J2801.2
unnamed: F2901.2, J2901.2
unnamed: F3001.2, J3001.2
unnamed: F3101.2, J3101.2
unnamed: F3201.2, J3201.2
unnamed: F3301.2, J3301.2
unnamed: F3401.2, J3401.2

Notes on the sheet:
Select input resistor based on input voltage. Max 50mA. 1k should allow for voltages 3.3 - 48V 2.4W
Either connect a dry contact between Pwr and In1 and enable power and ground jumpers, or disable both jumpers and feed In1 and In2 from external source.

Schematic: SelectableVoltageOutput.sch

Parts:
D1601: Green; LED_D5.0mm
D1602, D1603: CZRQR52C6V8-HF; D_0402_1005Metric
F1601: xA; Fuseholder_TR5_Littelfuse_No560_No460
J1601: Power_select; PinHeader_1x03_P2.54mm_Vertical
Q1601: Si2312CD; SOT-23
Q1602: Si2323CDS; SOT-23
R1601, R1604: 470; R_0805_2012Metric
R1602: 2.2k; R_0805_2012Metric
R1603: 1.65k; R_0805_2012Metric
R1605: 10k; R_0805_2012Metric

Connections:
12V_PWR: J1601.1; also elsewhere on the board
+5V: J1601.3; also elsewhere on the board
DO1: R1601.2, R1603.2, R1605.2; also elsewhere on the board
DO1_PWR: Q1602.3 (D); also elsewhere on the board
GND: D1601.1 (K), D1602.2 (A), Q1601.2 (S), R1605.1; also elsewhere on the board
unnamed: D1601.2 (A), R1603.1
unnamed: D1602.1 (K), Q1601.1 (G), R1601.1
unnamed: D1603.1 (K), F1601.1, Q1602.2 (S), R1602.1
unnamed: D1603.2 (A), Q1602.1 (G), R1604.1
unnamed: F1601.2, J1601.2
unnamed: Q1601.3 (D), R1602.2, R1604.2

Parts of its further copies:
D1701, D1801, D1901, D2001, D2101, D2201, D2301, D2601, D3202, D3302: Green; LED_D5.0mm
D1702, D1703, D1802, D1803, D1902, D1903, D2002, D2003, D2102, D2103, D2202, D2203, D2302, D2303, D2501, D2502, D3203, D3204, D3303, D3304: CZRQR52C6V8-HF; D_0402_1005Metric
F1701, F1801, F1901, F2001, F2101, F2201, F2301, F2601, F3202, F3302: xA; Fuseholder_TR5_Littelfuse_No560_No460
J1701, J1801, J1901, J2001, J2101, J2201, J2301, J2601, J3203, J3303: Power_select; PinHeader_1x03_P2.54mm_Vertical
Q1701, Q1801, Q1901, Q2001, Q2101, Q2201, Q2301, Q2501, Q3201, Q3301: Si2312CD; SOT-23
Q1702, Q1802, Q1902, Q2002, Q2102, Q2202, Q2302, Q2502, Q3202, Q3302: Si2323CDS; SOT-23
R1701, R1704, R1801, R1804, R1901, R1904, R2001, R2004, R2101, R2104, R2201, R2204, R2301, R2304, R2501, R2503, R3207, R3209, R3307, R3309: 470; R_0805_2012Metric
R1702, R1802, R1902, R2002, R2102, R2202, R2302, R2502, R3208, R3308: 2.2k; R_0805_2012Metric
R1703, R1803, R1903, R2003, R2103, R2203, R2303, R2603, R3206, R3306: 1.65k; R_0805_2012Metric
R1705, R1805, R1905, R2005, R2105, R2205, R2305, R2504, R3205, R3305: 10k; R_0805_2012Metric

Connections of its further copies:
12V_PWR: J1701.1, J1801.1, J1901.1, J2001.1, J2101.1, J2201.1, J2301.1, J3203.1, J3303.1; also elsewhere on the board
+5V: J1701.3, J1801.3, J1901.3, J2001.3, J2101.3, J2201.3, J2301.3, J3203.3, J3303.3; also elsewhere on the board
BELL_CTRL: R3305.2, R3306.2, R3307.2; also elsewhere on the board
BELL_PWR: Q3302.3 (D); also elsewhere on the board
DO2: R1701.2, R1703.2, R1705.2; also elsewhere on the board
DO2_PWR: Q1702.3 (D); also elsewhere on the board
DO3: R1801.2, R1803.2, R1805.2; also elsewhere on the board
DO3_PWR: Q1802.3 (D); also elsewhere on the board
DO4: R1901.2, R1903.2, R1905.2; also elsewhere on the board
DO4_PWR: Q1902.3 (D); also elsewhere on the board
DO5: R2001.2, R2003.2, R2005.2; also elsewhere on the board
DO5_PWR: Q2002.3 (D); also elsewhere on the board
DO6: R2101.2, R2103.2, R2105.2; also elsewhere on the board
DO6_PWR: Q2102.3 (D); also elsewhere on the board
DO7: R2201.2, R2203.2, R2205.2; also elsewhere on the board
DO7_PWR: Q2202.3 (D); also elsewhere on the board
DO8: R2301.2, R2303.2, R2305.2; also elsewhere on the board
DO8_PWR: Q2302.3 (D); also elsewhere on the board
EXTERNAL_SIREN_CTRL: R3205.2, R3206.2, R3207.2; also elsewhere on the board
GND: D1701.1 (K), D1702.2 (A), D1801.1 (K), D1802.2 (A), D1901.1 (K), D1902.2 (A), D2001.1 (K), D2002.2 (A), D2101.1 (K), D2102.2 (A), D2201.1 (K), D2202.2 (A), D2301.1 (K), D2302.2 (A), D3202.1 (K), D3203.2 (A), D3302.1 (K), D3303.2 (A), Q1701.2 (S), Q1801.2 (S), Q1901.2 (S), Q2001.2 (S), Q2101.2 (S), Q2201.2 (S), Q2301.2 (S), Q3201.2 (S), Q3301.2 (S), R1705.1, R1805.1, R1905.1, R2005.1, R2105.1, R2205.1, R2305.1, R3205.1, R3305.1; also elsewhere on the board
unnamed: D1701.2 (A), R1703.1
unnamed: D1702.1 (K), Q1701.1 (G), R1701.1
unnamed: D1703.1 (K), F1701.1, Q1702.2 (S), R1702.1
unnamed: D1703.2 (A), Q1702.1 (G), R1704.1
unnamed: D1801.2 (A), R1803.1
unnamed: D1802.1 (K), Q1801.1 (G), R1801.1
unnamed: D1803.1 (K), F1801.1, Q1802.2 (S), R1802.1
unnamed: D1803.2 (A), Q1802.1 (G), R1804.1
unnamed: D1901.2 (A), R1903.1
unnamed: D1902.1 (K), Q1901.1 (G), R1901.1
unnamed: D1903.1 (K), F1901.1, Q1902.2 (S), R1902.1
unnamed: D1903.2 (A), Q1902.1 (G), R1904.1
unnamed: D2001.2 (A), R2003.1
unnamed: D2002.1 (K), Q2001.1 (G), R2001.1
unnamed: D2003.1 (K), F2001.1, Q2002.2 (S), R2002.1
unnamed: D2003.2 (A), Q2002.1 (G), R2004.1
unnamed: D2101.2 (A), R2103.1
unnamed: D2102.1 (K), Q2101.1 (G), R2101.1
unnamed: D2103.1 (K), F2101.1, Q2102.2 (S), R2102.1
unnamed: D2103.2 (A), Q2102.1 (G), R2104.1
unnamed: D2201.2 (A), R2203.1
unnamed: D2202.1 (K), Q2201.1 (G), R2201.1
unnamed: D2203.1 (K), F2201.1, Q2202.2 (S), R2202.1
unnamed: D2203.2 (A), Q2202.1 (G), R2204.1
unnamed: D2301.2 (A), R2303.1
unnamed: D2302.1 (K), Q2301.1 (G), R2301.1
unnamed: D2303.1 (K), F2301.1, Q2302.2 (S), R2302.1
unnamed: D2303.2 (A), Q2302.1 (G), R2304.1
unnamed: D3202.2 (A), R3206.1
unnamed: D3203.1 (K), Q3201.1 (G), R3207.1
unnamed: D3204.1 (K), F3202.1, Q3202.2 (S), R3208.1
unnamed: D3204.2 (A), Q3202.1 (G), R3209.1
unnamed: D3302.2 (A), R3306.1
unnamed: D3303.1 (K), Q3301.1 (G), R3307.1
unnamed: D3304.1 (K), F3302.1, Q3302.2 (S), R3308.1
unnamed: D3304.2 (A), Q3302.1 (G), R3309.1
unnamed: F1701.2, J1701.2
unnamed: F1801.2, J1801.2
unnamed: F1901.2, J1901.2
unnamed: F2001.2, J2001.2
unnamed: F2101.2, J2101.2
unnamed: F2201.2, J2201.2
unnamed: F2301.2, J2301.2
unnamed: F3202.2, J3203.2
unnamed: F3302.2, J3303.2
unnamed: Q1701.3 (D), R1702.2, R1704.2
unnamed: Q1801.3 (D), R1802.2, R1804.2
unnamed: Q1901.3 (D), R1902.2, R1904.2
unnamed: Q2001.3 (D), R2002.2, R2004.2
unnamed: Q2101.3 (D), R2102.2, R2104.2
unnamed: Q2201.3 (D), R2202.2, R2204.2
unnamed: Q2301.3 (D), R2302.2, R2304.2
unnamed: Q3201.3 (D), R3208.2, R3209.2
unnamed: Q3301.3 (D), R3308.2, R3309.2
SIREN_PWR: Q3202.3 (D); also elsewhere on the board

Notes on the sheet:
Zener diodes and stop resisitors must be placed as close to mosfets as possible with shortest possible traces to reduce oscillation and reduce capacitance.

Schematic: 5VDigitalOutput.sch

Parts:
D2401: Green; LED_D5.0mm
Q2401: Si2312CD; SOT-23
Q2402: Si2323CDS; SOT-23
R2401: 10k; R_0805_2012Metric
R2402: 1.65k; R_0805_2012Metric
R2403, R2405: 120; R_0805_2012Metric
R2404: 4.7k; R_0805_2012Metric

Connections:
+5V: Q2402.2 (S), R2404.1; also elsewhere on the board
/DigitalIO/Internal siren/Output: Q2402.3 (D); also elsewhere on the board
GND: D2401.1 (K), Q2401.2 (S), R2401.1; also elsewhere on the board
INTERNAL_SIREN_CTRL: R2401.2, R2402.2, R2403.2; also elsewhere on the board
unnamed: D2401.2 (A), R2402.1
unnamed: Q2401.1 (G), R2403.1
unnamed: Q2401.3 (D), R2404.2, R2405.2
unnamed: Q2402.1 (G), R2405.1

Notes on the sheet:
Stop resisitors must be placed as close to mosfets as possible with shortest possible traces to reduce oscillation and reduce capacitance.

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
Board: 2 copper layers, 191.3 x 181.7 mm, 400 parts (0 on the bottom side), 256 nets.

## KiCad design G2/G2.kicad_pcb

Parts:
C201, C202, C203, C204: 100n; C_0805_2012Metric
C205, C206: 100u; CP_Radial_D6.3mm_P2.50mm
D201, D202: RBR3MM30ATR; D_SOD-123F
D203: 3.3V; D_SOD-123
D204: 5.1V; D_SOD-123
FL201: EMI_Filter_LCL; Pin_Header_Straight_1x03_Pitch2.54mm
J201, J202: GS2; Pin_Header_Straight_1x02_Pitch2.54mm
U201: LM1084-3.3; TO-263-3_TabPin2
U202: LM1084-5.0; TO-263-3_TabPin2

Connections:
+3V3: C203.1, C205.1, D203.1 (K), J201.1; also elsewhere on the board
+5V: C204.1, C206.1, D204.1 (K), J202.1; also elsewhere on the board
+12V: FL201.1; also elsewhere on the board
+12V_Filtered: D201.2 (A), D202.2 (A), FL201.3; also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, D203.2 (A), D204.2 (A), FL201.2, U201.1 (GND), U202.1 (GND); also elsewhere on the board
unnamed: C201.1, D201.1 (K), U201.3 (VI)
unnamed: C202.1, D202.1 (K), U202.3 (VI)
unnamed: J201.2, U201.2 (VO)
unnamed: J202.2, U202.2 (VO)

Notes on the sheet:
Max 5A / 16.5 W
Max 5A / 25W
3.5A / 41.5W

Parts:
C301, C302, C303, C304, C305, C306, C307, C308: 10u; CP_Elec_5x4.5
C309: 100n; C_0805_2012Metric
J301, J302, J303, J304, J305, J306, J307, J308: GS3; Pin_Header_Straight_1x03_Pitch2.54mm
J309, J310: Conn_02x08_Odd_Even; Pin_Header_Straight_2x08_Pitch2.54mm
J311, J312, J313, J314, J315, J316: Conn_01x09; MOLEX_1x9_39544-3009
Q301, Q302, Q303, Q304, Q305, Q306, Q307, Q308, Q310: ZXTN25050DFHTA; SOT-23
R301, R302, R303, R304, R305, R306, R307, R308: 1k; R_2512_6332Metric
R309, R310, R311, R312, R313, R314, R315, R316: 100; R_0805_2012Metric
R317, R318, R319, R320, R321, R322, R323, R324, R333: 10k; R_0805
R325, R326, R327, R328, R329, R330, R331, R332, R335: 470; R_0805_2012Metric
U301, U302, U303, U304, U305, U306, U307, U308: LTV-354T; SO-4_4.4x3.6mm_Pitch2.54mm
U309: MCP23017; SOIC-28W_7.5x17.9mm_Pitch1.27mm

Connections:
+3V3: C309.1, J310.2, R317.1, R318.1, R319.1, R320.1, R321.1, R322.1, R323.1, R324.1, R333.1, U309.9 (VCC), U309.18 (~RESET); also elsewhere on the board
+5V: J301.3, J302.3, J303.3, J304.3, J305.3, J306.3, J307.3, J308.3, J310.3, J316.6, J316.7, J316.8; also elsewhere on the board
+12V: J311.2; also elsewhere on the board
+12V_Filtered: J301.1, J302.1, J303.1, J304.1, J305.1, J306.1, J307.1, J308.1; also elsewhere on the board
/DigitalIO/DO1_GND_CTRL: J309.9, J311.4, Q301.2 (C)
/DigitalIO/DO2_GND_CTRL: J309.11, J311.6, Q302.2 (C)
/DigitalIO/DO3_GND_CTRL: J309.13, J311.8, Q303.2 (C)
/DigitalIO/DO4_GND_CTRL: J309.15, J312.1, Q304.2 (C)
/DigitalIO/DO5_GND_CTRL: J309.16, J312.3, Q305.2 (C)
/DigitalIO/DO6_GND_CTRL: J309.14, J312.5, Q306.2 (C)
/DigitalIO/DO7_GND_CTRL: J309.12, J312.7, Q307.2 (C)
/DigitalIO/DO8_GND_CTRL: J309.10, J312.9, Q308.2 (C)
ANALOG_I2C_SCL: J310.15; also elsewhere on the board
ANALOG_I2C_SDA: J310.14; also elsewhere on the board
ANALOG_RDY_1: J310.12; also elsewhere on the board
ANALOG_RDY_2: J310.13; also elsewhere on the board
BELL: J316.9, Q310.2 (C)
BELL_CTRL: J310.10, R335.2
DI1: J309.1, R309.1, R317.2, U301.4, U309.21 (GPA0)
DI1_1: J314.1, R301.2
DI1_2: J314.2, U301.2
DI2: J309.3, R310.1, R318.2, U302.4, U309.22 (GPA1)
DI2_1: J314.3, R302.2
DI2_2: J314.4, U302.2
DI3: J309.5, R311.1, R319.2, U303.4, U309.23 (GPA2)
DI3_1: J314.5, R303.2
DI3_2: J314.6, U303.2
DI4: J309.7, R312.1, R320.2, U304.4, U309.24 (GPA3)
DI4_1: J314.7, R304.2
DI4_2: J314.8, U304.2
DI5: J309.2, R313.1, R321.2, U305.4, U309.25 (GPA4)
DI5_1: J314.9, R305.2
DI5_2: J315.1, U305.2
DI6: J309.4, R314.1, R322.2, U306.4, U309.26 (GPA5)
DI6_1: J315.2, R306.2
DI6_2: J315.3, U306.2
DI7: J309.6, R315.1, R323.2, U307.4, U309.27 (GPA6)
DI7_1: J315.4, R307.2
DI7_2: J315.5, U307.2
DI8: J309.8, R316.1, R324.2, U308.4, U309.28 (GPA7)
DI8_1: J315.6, R308.2
DI8_2: J315.7, U308.2
DIA_Interrupt: J310.11, R333.2, U309.20 (INTA)
DIGITAL_I2C_SCL: J310.5, U309.12 (SCL)
DIGITAL_I2C_SDA: J310.6, U309.13 (SDA)
DO1: R325.2, U309.1 (GPB0)
DO1_PWR: J301.2, J311.3
DO2: R326.2, U309.2 (GPB1)
DO2_PWR: J302.2, J311.5
DO3: R327.2, U309.3 (GPB2)
DO3_PWR: J303.2, J311.7
DO4: R328.2, U309.4 (GPB3)
DO4_PWR: J304.2, J311.9
DO5: R329.2, U309.5 (GPB4)
DO5_PWR: J305.2, J312.2
DO6: R330.2, U309.6 (GPB5)
DO6_PWR: J306.2, J312.4
DO7: R331.2, U309.7 (GPB6)
DO7_PWR: J307.2, J312.6
DO8: R332.2, U309.8 (GPB7)
DO8_PWR: J308.2, J312.8
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, J310.1, J310.16, J311.1, J313.2, J313.5, J313.8, J316.2, J316.4, J316.5, Q301.3 (E), Q302.3 (E), Q303.3 (E), Q304.3 (E), Q305.3 (E), Q306.3 (E), Q307.3 (E), Q308.3 (E), Q310.3 (E), U301.3, U302.3, U303.3, U304.3, U305.3, U306.3, U307.3, U308.3, U309.10 (GND), U309.15 (A0), U309.16 (A1), U309.17 (A2); also elsewhere on the board
unnamed: C301.1, R309.2
unnamed: C302.1, R310.2
unnamed: C303.1, R311.2
unnamed: C304.1, R312.2
unnamed: C305.1, R313.2
unnamed: C306.1, R314.2
unnamed: C307.1, R315.2
unnamed: C308.1, R316.2
unnamed: Q301.1 (B), R325.1
unnamed: Q302.1 (B), R326.1
unnamed: Q303.1 (B), R327.1
unnamed: Q304.1 (B), R328.1
unnamed: Q305.1 (B), R329.1
unnamed: Q306.1 (B), R330.1
unnamed: Q307.1 (B), R331.1
unnamed: Q308.1 (B), R332.1
unnamed: Q310.1 (B), R335.1
unnamed: R301.1, U301.1
unnamed: R302.1, U302.1
unnamed: R303.1, U303.1
unnamed: R304.1, U304.1
unnamed: R305.1, U305.1
unnamed: R306.1, U306.1
unnamed: R307.1, U307.1
unnamed: R308.1, U308.1
Sense1_DUT: J313.1; also elsewhere on the board
Sense2_DUT: J313.3; also elsewhere on the board
Sense3_DUT: J313.4; also elsewhere on the board
Sense4_DUT: J313.6; also elsewhere on the board
Sense5_DUT: J313.7; also elsewhere on the board
Sense6_DUT: J313.9; also elsewhere on the board
Sense7_DUT: J316.1; also elsewhere on the board
Sense8_DUT: J316.3; also elsewhere on the board
Wiegand_D0: J310.7, J315.8
Wiegand_D1: J310.8, J315.9

Notes on the sheet:
Select based on input voltage. Max 50mA. 1k should allow for voltages 3.3 - 48V 2.4W
Adress 0x20
Near MCP23017
To status card
To MCU

Parts:
C401, C402: 100n; C_0805_2012Metric
CON401: AVR-JTAG-10; IDC-Header_2x05_P2.54mm_Vertical
J401: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J402: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J403: Conn_02x04_Counter_Clockwise; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W8.61mm_P2.54mm_LowProfile
J404: Conn_01x08; WE68710814022_8x0.50mm_SMT_ZIF_Horizontal_Top
JP401: Jumper; Pin_Header_Straight_1x02_Pitch2.54mm
R401, R402, R403, R404, R405, R406, R407, R408, R409, R410, R411, R413, R414: 10k; R_0805
SPRKESP32401: Spark_ESP32Thing; Sparkfun_ESP32Thing
U401: TXB0102DCU; VSSOP-8_2.4x2.1mm_Pitch0.5mm

Connections:
+3V3_C: C401.1, CON401.4 (VREF), J402.2, J403.1, J403.2, J403.3, J403.4, J404.5, J404.6, JP401.1, R401.1, R402.1, R403.1, R404.1, R406.1, R407.2, R408.1, R409.1, U401.3 (VCCA)
+5V_C: C402.2, J402.3, J404.3, J404.4, U401.7 (VCCB)
/MCU/ANALOG_I2C_SCL: J402.15, R407.1, SPRKESP32401.9 (DAC1/ADC2_8/GPIO25)
/MCU/ANALOG_I2C_SDA: J402.14, R409.2, SPRKESP32401.10 (DAC2/ADC2_9/GPIO26)
/MCU/ANALOG_RDY_1: J402.12, SPRKESP32401.7 (VDETI/ADC1_6/GPI34)
/MCU/ANALOG_RDY_2: J402.13, SPRKESP32401.8 (VDET2/ADC1_7/GPI35)
/MCU/BELL_CTRL: J402.10, SPRKESP32401.5 (Touch9/ADC1_4/GPIO32/XTAL32)
/MCU/DIA_Interrupt: J402.11, SPRKESP32401.6 (Touch8/ADC1_5/GPIO33/XTAL32)
/MCU/DIGITAL_I2C_SCL: J402.5, R406.2, SPRKESP32401.26 (U2_RXD/GPIO16)
/MCU/DIGITAL_I2C_SDA: J402.6, R408.2, SPRKESP32401.27 (U2_TXD/GPIO17)
/MCU/IO_1: J401.2, SPRKESP32401.33 (V_SPI_CLK/GPIO18/SCK)
/MCU/IO_2: J401.3, SPRKESP32401.34 (V_SPI_D/GPIO23/MOSI)
/MCU/IO_3: J401.4, SPRKESP32401.35 (U0_CTS/V_SPI_Q/GPIO19/MISO)
/MCU/IO_4: J401.5, SPRKESP32401.36 (U0_RTS/V_SPI_WP/GPIO22/SCL)
/MCU/IO_5: J401.6, SPRKESP32401.37 (U0_RXD/GPIO3/CLK2)
/MCU/IO_6: J401.7, SPRKESP32401.38 (U0_TXD/GPIO1/CLK3)
/MCU/IO_7: J401.8, SPRKESP32401.39 (V_SPI_HD/GPIO21/SDA)
/MCU/LEVEL_SHIFTER_ENABLE: J404.7, R405.1, SPRKESP32401.32 (LED(blue)/V_SPI_CS0/GPIO5), U401.6 (OE)
/MCU/RGB_LED_DATA_CTRL: J404.8, SPRKESP32401.30 (Touch2/HSPI_WP/ADC2_2/GPIO2/CS)
/MCU/Wiegand_D0: J402.7, U401.8 (B1)
/MCU/Wiegand_D1: J402.8, U401.1 (B2)
GND_C: C401.2, C402.1, CON401.2 (GND), CON401.10 (GND), J401.1, J402.1, J402.16, J404.1, J404.2, R405.2, R410.1, R411.1, R413.1, R414.1, SPRKESP32401.17 (GND), SPRKESP32401.20 (GND), SPRKESP32401.21 (GND), SPRKESP32401.24 (GND), SPRKESP32401.40 (GND), U401.2 (GND)
JTAG:MTCK: CON401.1 (TCK), R401.2, SPRKESP32401.14 (Touch4/HSP_ID/ADC2_4/GPIO13)
JTAG:MTDO: CON401.3 (TDO), R402.2, SPRKESP32401.31 (Touch3/HSPI_CS0/ADC2_3/GPIO15)
JTAG_MTDI: CON401.9 (TDI), R404.2, SPRKESP32401.13 (Touch5/HSPI_Q/ADC2_5/GPIO12)
JTAG_MTMS: CON401.5 (TMS), R403.2, SPRKESP32401.12 (Touch6/HSPI_CLK/ADC2_6/GPIO14)
unnamed: J403.5, R414.2, SPRKESP32401.4 (ADC1_3/GPI39/SensVN)
unnamed: J403.6, R413.2, SPRKESP32401.3 (ACD1_2/GPI38/CapVN)
unnamed: J403.7, R411.2, SPRKESP32401.2 (ADC1_1/GPI37/CapVP)
unnamed: J403.8, R410.2, SPRKESP32401.1 (ADC1_0/GPI36/SenseVP)
unnamed: JP401.2, SPRKESP32401.16 (3V3), SPRKESP32401.25 (3V3)
unnamed: SPRKESP32401.28 (Touch0/HSPI_HD/ADC2_0/GPIO4), U401.4 (A2)
unnamed: SPRKESP32401.29 (Button/Touch1/ADC2_1/GPIO0/CLK1), U401.5 (A1)
~RESET: CON401.6 (~SRST), SPRKESP32401.15 (~RST)

Notes on the sheet:
To Status
To backplane
To MCU
