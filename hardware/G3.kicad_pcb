# Repository PerMalmberg/IO-Card-G3 (continued)

## KiCad design G2/G2.kicad_pcb (continued)

Parts:
C501, C502, C503, C504, C505, C506, C507, C508, C509, C510: 100n; C_0805_2012Metric
D501, D502, D503, D504, D505, D506, D519, D520: CDBA3100-HF; D_SMA
D507, D508, D509, D510, D511, D512, D513, D514, D515, D516, D517, D518, D521, D522, D523, D524: STPS0560Z; D_SOD-123
R501, R502, R503, R504, R505, R506, R519, R520: 1k; R_0805_2012Metric
R507, R508, R509, R510, R511, R512, R521, R522: 2k; R_0805_2012Metric
R513, R514, R515, R516, R517, R518, R523, R524: 100; R_0805_2012Metric
R525, R526: 10k; R_0805
RV501, RV502, RV503, RV505, RV506, RV507, RV508: B72510E250K062; C_0805_2012Metric
RV504: B72510E250K62; C_0805_2012Metric
U501, U502: ADS1115IDGST; SOP50P490X110-10N

Connections:
+3V3: C509.1, C510.1, R525.1, R526.1, U501.1 (ADDR), U501.8 (VDD), U502.8 (VDD); also elsewhere on the board
+5V: D507.1 (K), D509.1 (K), D511.1 (K), D513.1 (K), D515.1 (K), D517.1 (K), D521.1 (K), D523.1 (K), R507.1, R508.1, R509.1, R510.1, R511.1, R512.1, R521.1, R522.1; also elsewhere on the board
ANALOG_I2C_SCL: U501.10 (SCL), U502.10 (SCL); also elsewhere on the board
ANALOG_I2C_SDA: U501.9 (SDA), U502.9 (SDA); also elsewhere on the board
ANALOG_RDY_1: R525.2, U502.2 (ALERT/RDY); also elsewhere on the board
ANALOG_RDY_2: R526.2, U501.2 (ALERT/RDY); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, D501.2 (A), D502.2 (A), D503.2 (A), D504.2 (A), D505.2 (A), D506.2 (A), D508.2 (A), D510.2 (A), D512.2 (A), D514.2 (A), D516.2 (A), D518.2 (A), D519.2 (A), D520.2 (A), D522.2 (A), D524.2 (A), RV501.1, RV502.1, RV503.1, RV504.1, RV505.1, RV506.1, RV507.1, RV508.1, U501.3 (GND), U502.1 (ADDR), U502.3 (GND); also elsewhere on the board
unnamed: C501.1, D507.2 (A), D508.1 (K), R501.2, R507.2, R513.1
unnamed: C502.1, D509.2 (A), D510.1 (K), R502.2, R508.2, R514.1
unnamed: C503.1, D511.2 (A), D512.1 (K), R503.2, R509.2, R515.1
unnamed: C504.1, D513.2 (A), D514.1 (K), R504.2, R510.2, R516.1
unnamed: C505.1, D515.2 (A), D516.1 (K), R505.2, R511.2, R517.1
unnamed: C506.1, D517.2 (A), D518.1 (K), R506.2, R512.2, R518.1
unnamed: C507.1, D521.2 (A), D522.1 (K), R519.2, R521.2, R523.1
unnamed: C508.1, D523.2 (A), D524.1 (K), R520.2, R522.2, R524.1
Sense1: R513.2, U502.4 (AIN0)
Sense1_DUT: D501.1 (K), R501.1, RV501.2; also elsewhere on the board
Sense2: R514.2, U502.5 (AIN1)
Sense2_DUT: D502.1 (K), R502.1, RV502.2; also elsewhere on the board
Sense3: R515.2, U502.6 (AIN2)
Sense3_DUT: D503.1 (K), R503.1, RV503.2; also elsewhere on the board
Sense4: R516.2, U502.7 (AIN3)
Sense4_DUT: D504.1 (K), R504.1, RV504.2; also elsewhere on the board
Sense5: R517.2, U501.4 (AIN0)
Sense5_DUT: D505.1 (K), R505.1, RV505.2; also elsewhere on the board
Sense6: R518.2, U501.5 (AIN1)
Sense6_DUT: D506.1 (K), R506.1, RV506.2; also elsewhere on the board
Sense7: R523.2, U501.6 (AIN2)
Sense7_DUT: D519.1 (K), R519.1, RV507.2; also elsewhere on the board
Sense8: R524.2, U501.7 (AIN3)
Sense8_DUT: D520.1 (K), R520.1, RV508.2; also elsewhere on the board

Notes on the sheet:
I2C address: 0x49
Near ADS1115:2
Near ADS1115:1
I2C address: 0x48

Parts:
C601, C602, C603, C604, C605, C606, C607: 100n; C_0805_2012Metric
D601, D602, D603, D604, D605, D606, D607, D608: Green; LED_0805
D609, D610, D611, D612, D613, D614, D615, D616: Red; LED_0805
J601: Conn_02x08_Odd_Even; Pin_Header_Straight_2x08_Pitch2.54mm_SMD
J602: Conn_01x08; WE68710814022_8x0.50mm_SMT_ZIF_Horizontal_Top
LED601, LED602, LED603, LED604, LED605: WS2812B; LED_WS2812B-PLCC4
R601, R602, R603, R604, R605, R606, R607, R608: 56; R_0805_2012Metric
R609, R610, R611, R612, R613, R614, R615, R616: 68; R_0805_2012Metric
U601: TXB0102DCU; VSSOP-8_2.4x2.1mm_Pitch0.5mm

Connections:
+3V3_S: C601.2, J602.5, J602.6, R601.2, R602.2, R603.2, R604.2, R605.2, R606.2, R607.2, R608.2, R609.2, R610.2, R611.2, R612.2, R613.2, R614.2, R615.2, R616.2, U601.3 (VCCA)
+5V_S: C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, J602.3, J602.4, LED601.1 (VDD), LED602.1 (VDD), LED603.1 (VDD), LED604.1 (VDD), LED605.1 (VDD), U601.7 (VCCB)
/Status/LEVEL_SHIFTER_ENABLE: J602.7, U601.6 (OE)
/Status/RGB_LED_DATA_CTRL: J602.8, U601.5 (A1)
GND_S: C601.1, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, J602.1, J602.2, LED601.3 (VSS), LED602.3 (VSS), LED603.3 (VSS), LED604.3 (VSS), LED605.3 (VSS), U601.2 (GND)
unnamed: D601.1 (K), J601.8
unnamed: D601.2 (A), R601.1
unnamed: D602.1 (K), J601.6
unnamed: D602.2 (A), R602.1
unnamed: D603.1 (K), J601.4
unnamed: D603.2 (A), R603.1
unnamed: D604.1 (K), J601.2
unnamed: D604.2 (A), R604.1
unnamed: D605.1 (K), J601.7
unnamed: D605.2 (A), R605.1
unnamed: D606.1 (K), J601.5
unnamed: D606.2 (A), R606.1
unnamed: D607.1 (K), J601.3
unnamed: D607.2 (A), R607.1
unnamed: D608.1 (K), J601.1
unnamed: D608.2 (A), R608.1
unnamed: D609.1 (K), J601.10
unnamed: D609.2 (A), R609.1
unnamed: D610.1 (K), J601.12
unnamed: D610.2 (A), R610.1
unnamed: D611.1 (K), J601.14
unnamed: D611.2 (A), R611.1
unnamed: D612.1 (K), J601.16
unnamed: D612.2 (A), R612.1
unnamed: D613.1 (K), J601.15
unnamed: D613.2 (A), R613.1
unnamed: D614.1 (K), J601.13
unnamed: D614.2 (A), R614.1
unnamed: D615.1 (K), J601.11
unnamed: D615.2 (A), R615.1
unnamed: D616.1 (K), J601.9
unnamed: D616.2 (A), R616.1
unnamed: LED601.2 (DOUT), LED602.4 (DIN)
unnamed: LED601.4 (DIN), U601.8 (B1)
unnamed: LED602.2 (DOUT), LED603.4 (DIN)
unnamed: LED603.2 (DOUT), LED604.4 (DIN)
unnamed: LED604.2 (DOUT), LED605.4 (DIN)

Notes on the sheet:
To Backplane
Digial inputs
Digital outputs
To MCU

Board: 2 copper layers, 156.2 x 187.5 mm, 232 parts (47 on the bottom side), 193 nets.

## Commit log (part)

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2017-09-17 STarted project. Added PCB edge cuts matching Bud Industries DBM-4774 casing.
2017-09-17 Placed Molex connectors.
2017-09-19 Single card with V-Grooves
2017-09-21 Completed digital IO. Begun analog sensing.
2017-09-24 Begun layout.
2017-09-26 More layout
2017-09-30 Layout nearly complete, only LCD left
2017-10-01 Layout completed. No display - it won't fit in the enclosure
2017-10-01 DRC run. Removed PDF docs.
2017-10-03 Added name information
2017-11-11 Fixed backwards connected TXB0102DCUs. Fixed rgb led ctrl being connected instead of level shift enable to TXB0102DCU. Made the hole for IRD contact larger. Increased hole size for screw terminals
2017-11-12 Swapped wires on flat cable socket since it is mounted on the backside
2017-11-12 Removed leftover traces in schematic
2017-11-20 Added component data sheets and names
2017-11-30 Updated component name (was missing a digit)
2018-01-08 Removed I2C power control
2018-03-25 Step two of conversion to v5 format
2018-03-25 Removed rescue files and connected the last few wires in the PCB.
2018-08-01 Renamed to G3
2018-08-01 Cleaned up to start new design
2018-08-19 Most stuff in place.
2018-08-19 Changed from DIP swtich to pin header for address setting.
2018-09-01 More touch ups
2018-09-02 Added header for BME280
2018-09-10 UART TX/RX fixed
2018-09-10 PCB updated from schematic.
2018-09-13 Using MAX4948 instead of DIPs
2018-09-15 Use smaller TR5 fuse holders
2018-09-16 Changes to input and outputs
2018-09-17 WiP PCB
2018-09-23 Texts and moutningholes.
2018-09-25 Text adjustements. Added OS H/W Logo. Added PCB manufacturing files.
2018-09-26 Save before committing...
2018-10-07 Changed pin header spec to one without hook.
2018-10-17 Added rendering of the PCB
2018-10-17 Spelling
2018-10-21 #WiP: CMake. Use new smooth version
2018-11-10 Main and I2CTask added.
2018-11-11 #1 SD_ENABLE removed; pin grounded. #7 All pins on seconds MCP2317 used. Updated I2CTask to match new H/W layout. Closes #1. Closes #7.
2018-11-11 #6 Switched SIREN_CTRL and SD_SPI_MOSI.
2018-11-11 #4 Added test points to MAX4948. Closes #4.
2018-11-11 Started to re-route PCB for schematics changes.
2018-11-14 PCB DRC Ok. Removed test points for MAX4948, takes up too much space.
2018-11-17 More ground vias. Moved text label
2018-11-17 Text update. New manufacturing files.
2018-11-20 Added BME280 read and value publishing.
2018-11-24 - Initialization of SD Card. - Wifi - SNTP - Status LEDs
2018-11-25 Fix formatting.
2018-12-01 Added partition table. No longer reads BME280 if it is not detected ad boot.
2018-12-06 Use positive logic.
2018-12-08 Builds with IDF as library. Meny config still not functional.
2018-12-08 Updated smooth submodule
2018-12-09 Update submodule Smooth
2018-12-09 Device ID read from disk (or generated)
2018-12-14 Publish read raw values.
2018-12-15 Namespaces and file locations.
2018-12-19 Added AlarmConfig
2018-12-21 More work on the alarm parts.
2018-12-22 More on alarm part.
2018-12-22 Removed zone concept from drawing.
2018-12-23 More on alarm parts.
2018-12-25 Changed numbering of analog inputs.
2018-12-25 Publish triggered/restored alarm sensors.
2019-01-08 Replaced TXB0102DCU with SN74LV4T125. Closes #13
2019-01-09 Updated PCB manufacturing files.
2019-01-12 Start alarm before wifi because to makes sense.
2019-01-20 Preparing to replicate layout for outputs.
2019-01-21 Updated PCB with additional vias. Added decoupler caps for Wiegand.
2019-01-26 Added <id>/io/set/<no> command.
2019-01-27 Updated smooth
2019-01-27 Renamed internal siren to buzzer.
2019-02-10 Implemented keypad/keycard support.
2019-02-10 Changed loging for keypad entry.
2019-02-18 WiP: Implemented sound player
2019-02-21 Rename class for clarity.
2019-02-23 Reduced tick interval to better utilize the interrupt triggers.
2019-02-26 Updated readme with all config file examples.
2019-06-21 Builds against latest Smooth library.
2019-06-22 Specify sdkconfig file.
2019-08-10 Using updated Smooth.
2019-08-10 Use new Smooth version.
2019-08-11 Linker error fixed.
2019-08-18 Sensor data published via Websocket.
2019-08-20 Prepare to build for Linux.
2019-08-25 #16 - Begun work on web UI
2019-08-31 Use new Smooth version
2019-09-08 #16 - All fields tied up.
2019-09-08 Digital input and output status displayed.
2019-09-10 All input/output statuses displayed.
2019-09-14 Better status indication.
2019-09-15 Set title
2019-09-15 Formatting
2019-09-15 Use correct url when used on device.
2019-09-19 Use new Wiegand implementation.
2019-09-21 Display armed state on LED and on web page.
2019-09-21 Refresh armed status for web page every tick.
2019-10-13 Update smooth.
2019-10-19 Update smooth submodule.
2020-06-07 Bump websocket-extensions from 0.1.3 to 0.1.4 in /software/web_root
    Bumps [websocket-extensions](https://github.com/faye/websocket-extensions-node) from 0.1.3 to 0.1.4.
    - [Release notes](https://github.com/faye/websocket-extensions-node/releases)
    - [Changelog](https://github.com/faye/websocket-extensions-node/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/faye/websocket-extensions-node/compare/0.1.3...0.1.4)
2020-07-31 Bump elliptic from 6.4.1 to 6.5.3 in /software/web_root
    Bumps [elliptic](https://github.com/indutny/elliptic) from 6.4.1 to 6.5.3.
    - [Release notes](https://github.com/indutny/elliptic/releases)
    - [Commits](https://github.com/indutny/elliptic/compare/v6.4.1...v6.5.3)
2020-11-25 Bump highlight.js from 9.15.10 to 9.18.5 in /software/web_root
    Bumps [highlight.js](https://github.com/highlightjs/highlight.js) from 9.15.10 to 9.18.5.
    - [Release notes](https://github.com/highlightjs/highlight.js/releases)
    - [Changelog](https://github.com/highlightjs/highlight.js/blob/9.18.5/CHANGES.md)
    - [Commits](https://github.com/highlightjs/highlight.js/compare/9.15.10...9.18.5)
2021-03-30 Bump y18n from 3.2.1 to 4.0.1 in /software/web_root
    Bumps [y18n](https://github.com/yargs/y18n) from 3.2.1 to 4.0.1.
    - [Release notes](https://github.com/yargs/y18n/releases)
    - [Changelog](https://github.com/yargs/y18n/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/yargs/y18n/commits)
2021-05-10 Bump lodash from 3.10.1 to 4.17.21 in /software/web_root
    Bumps [lodash](https://github.com/lodash/lodash) from 3.10.1 to 4.17.21.
    - [Release notes](https://github.com/lodash/lodash/releases)
    - [Commits](https://github.com/lodash/lodash/compare/3.10.1...4.17.21)
2021-05-25 Bump browserslist from 4.6.6 to 4.16.6 in /software/web_root
    Bumps [browserslist](https://github.com/browserslist/browserslist) from 4.6.6 to 4.16.6.
    - [Release notes](https://github.com/browserslist/browserslist/releases)
    - [Changelog](https://github.com/browserslist/browserslist/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/browserslist/browserslist/compare/4.6.6...4.16.6)
2021-05-29 Bump ws from 1.1.2 to 6.2.1 in /software/web_root
    Bumps [ws](https://github.com/websockets/ws) from 1.1.2 to 6.2.1.
    - [Release notes](https://github.com/websockets/ws/releases)
    - [Commits](https://github.com/websockets/ws/compare/1.1.2...6.2.1)
2021-08-11 Bump path-parse from 1.0.6 to 1.0.7 in /software/web_root
    Bumps [path-parse](https://github.com/jbgutierrez/path-parse) from 1.0.6 to 1.0.7.
    - [Release notes](https://github.com/jbgutierrez/path-parse/releases)
    - [Commits](https://github.com/jbgutierrez/path-parse/commits/v1.0.7)
    ---
    updated-dependencies:
    - dependency-name: path-parse
2021-10-06 Bump url-parse from 1.4.7 to 1.5.3 in /software/web_root
    Bumps [url-parse](https://github.com/unshiftio/url-parse) from 1.4.7 to 1.5.3.
    - [Release notes](https://github.com/unshiftio/url-parse/releases)
    - [Commits](https://github.com/unshiftio/url-parse/compare/1.4.7...1.5.3)
    ---
    updated-dependencies:
    - dependency-name: url-parse
2022-02-12 Bump follow-redirects from 1.5.8 to 1.14.8 in /software/web_root
    Bumps [follow-redirects](https://github.com/follow-redirects/follow-redirects) from 1.5.8 to 1.14.8.
    - [Release notes](https://github.com/follow-redirects/follow-redirects/releases)
    - [Commits](https://github.com/follow-redirects/follow-redirects/compare/v1.5.8...v1.14.8)
    ---
    updated-dependencies:
    - dependency-name: follow-redirects
2022-02-26 Bump url-parse from 1.4.7 to 1.5.10 in /software/web_root
    Bumps [url-parse](https://github.com/unshiftio/url-parse) from 1.4.7 to 1.5.10.
    - [Release notes](https://github.com/unshiftio/url-parse/releases)
    - [Commits](https://github.com/unshiftio/url-parse/compare/1.4.7...1.5.10)
    ---
    updated-dependencies:
    - dependency-name: url-parse
2022-06-22 Bump shell-quote from 1.7.1 to 1.7.3 in /software/web_root
    Bumps [shell-quote](https://github.com/substack/node-shell-quote) from 1.7.1 to 1.7.3.
    - [Release notes](https://github.com/substack/node-shell-quote/releases)
    - [Changelog](https://github.com/substack/node-shell-quote/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/substack/node-shell-quote/compare/v1.7.1...1.7.3)
    ---
    updated-dependencies:
2022-07-20 Bump terser from 4.2.1 to 4.8.1 in /software/web_root
    Bumps [terser](https://github.com/terser/terser) from 4.2.1 to 4.8.1.
    - [Release notes](https://github.com/terser/terser/releases)
    - [Changelog](https://github.com/terser/terser/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/terser/terser/commits)
    ---
    updated-dependencies:
2022-11-18 Bump loader-utils and @vue/cli-service in /software/web_root
    Bumps [loader-utils](https://github.com/webpack/loader-utils) to 1.4.2 and updates ancestor dependency [@vue/cli-service](https://github.com/vuejs/vue-cli/tree/HEAD/packages/@vue/cli-service). These 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
    Updates `loader-utils` from 1.2.3 to 1.4.2
    - [Release notes](https://github.com/webpack/loader-utils/releases)
    - [Changelog](https://github.com/webpack/loader-utils/blob/v1.4.2/CHANGELOG.md)
    - [Commits](https://github.com/webpack/loader-utils/compare/v1.2.3...v1.4.2)
    Updates `@vue/cli-service` from 3.11.0 to 5.0.8
2022-12-09 Bump qs from 6.5.2 to 6.5.3 in /software/web_root
    Bumps [qs](https://github.com/ljharb/qs) from 6.5.2 to 6.5.3.
    - [Release notes](https://github.com/ljharb/qs/releases)
    - [Changelog](https://github.com/ljharb/qs/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/ljharb/qs/compare/v6.5.2...v6.5.3)
    ---
    updated-dependencies:
2023-01-04 Bump json5, @vue/cli-plugin-babel and @vue/cli-service
    Bumps [json5](https://github.com/json5/json5) to 2.2.3 and updates ancestor dependencies [json5](https://github.com/json5/json5), [@vue/cli-plugin-babel](https://github.com/vuejs/vue-cli/tree/HEAD/pa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
    Updates `json5` from 1.0.1 to 2.2.3
    - [Release notes](https://github.com/json5/json5/releases)
    - [Changelog](https://github.com/json5/json5/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/json5/json5/compare/v1.0.1...v2.2.3)
    Updates `@vue/cli-plugin-babel` from 3.
2024-02-18 Bump follow-redirects from 1.5.8 to 1.15.5 in /software/web_root
    Bumps [follow-redirects](https://github.com/follow-redirects/follow-redirects) from 1.5.8 to 1.15.5.
    - [Release notes](https://github.com/follow-redirects/follow-redirects/releases)
    - [Commits](https://github.com/follow-redirects/follow-redirects/compare/v1.5.8...v1.15.5)
    ---
    updated-dependencies:
    - dependency-name: follow-redirects
2024-02-18 Bump fsevents from 1.2.4 to 1.2.13 in /software/web_root
    Bumps [fsevents](https://github.com/fsevents/fsevents) from 1.2.4 to 1.2.13.
    - [Release notes](https://github.com/fsevents/fsevents/releases)
    - [Commits](https://github.com/fsevents/fsevents/compare/v1.2.4...v1.2.13)
    ---
    updated-dependencies:
    - dependency-name: fsevents
