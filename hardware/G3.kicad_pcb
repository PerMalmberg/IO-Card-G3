# Repository PerMalmberg/IO-Card-G3

File README.md:

# IO-Card G3

This is my custom I/O card, third generation. Main purpose is to serve as an alarm system.

## Hardware features

- 8 analog inputs for detecting changes in resistance (a.k.a balanced line).
- 8 digital inputs, 3.3-24V
- 8 digital outputs, 5/12V, fused.
- 6 controllable status LED.
- Optional BME280
- Wiegand interface
- On-board buzzer.
- SD Card (SPI and MMC bus selectable)
- JTAG debugging (when SD Card is using SPI)
- LED indicators for all input and outputs.
- Screw terminals for all interfaces.
- MCU: ESP32 Wrover Module
- Powered by 12V DC.

## Software

- Web interface for configuration and status monitoring.
- MQTT for control and monitoring.

### Software overview

#### Feature specification / task list

- NTP
  Based on config, synchronize clock with NTP server every 15 minutes.
- I2C
  - On interrupt on `ANALOG_RDY_1` or `ANALOG_RDY_2`, read analog values; publish internally.
  - On interrupt on `DIA_Interrupt`, read digital input values; publish internally.
  - Periodically read BME280 values and publish internally (&lt;id&gt;/io/status/sensor)
  - Receive control events and set digital outputs accordingly.
    - Also handle `SIREN_CTRL`, even though it is not on the I2C bus.
- MQTT
  - All payloads must be JSON-formated.
  - Periodically publish all I/O statuses on the following topics:
    - `<ID>`/io/status/digital/input/&lt;number&gt;
    - `<ID>`/io/status/digital/output/&lt;number&gt;
    - `<ID>`/io/status/analog/input/&lt;number&gt;
    - `<ID>`/io/status/buzzer
    - `<ID>`/io/status/siren
    - Publish Wiegand button sequences on topic `<ID>`/io/status/wiegand
    - If enabled in configuration, allow I/O to be controlled via topic `<ID>/io/set/channel_no`, where `channel_no` is a number between 0 and 7.
  - All published items shall have a `unix_timestamp` value which tells when the item was created.
  - a value of `true` shall be interpreted as 'active', regardless if the input/output is active high or low. i.e. if the buzzer is making sounds, the the status is `true`.
  - All topics can be renamed via configuration.
    - The special string `@ID@` is used to signify the ID of the device. Any instance of it in the replacement topic will be replaced with the device ID.
    - Once a topic is renamed, the original one ceases to function until the renaming is removed from the configuration.
- Wiegand
  - Listen to button presses and publish internally.  
  - Each series must end with the `execute_button` button, usually '#' (but as its numerical button value). Any press on the `cancel_button` (*) clears any already entered numbers from the buffer.
  - If no input is received during `entry_timeout` milliseconds, the bufer is cleared and no number series is published.
- Alarm
  - Based on configuration, do:
    - Play sound using the buzzer when any armed I/O with an `entry_delay` larger than 0 changes state, for the duration of the delay.
    - Sound siren for X minutes when any input marked as `armed` no longer matches its configured `armed_state`. For analog inputs this means a value outside the range of `value` +/- `allowed_hysteresis`.
      - Delay for the configured `entry_delay` if the triggering input has one larger than 0. Immediately sound the siren if an input other than the first is triggered during the wait time.
    - Silence siren after X minutes, regardless if an IO marked as `armed` has returned to its `armed_state` or not.
      - Do not sound the siren again until after Y minutes.
    - Inputs with `active` set to `false` are never considered for any operation.

#### Startup procedure

- Initialize I2C Bus.
  - 2x MCP23017
  - 2x ADS1115IDGST
  - Optional BME280.
- Read `SD_ENABLE` to determine the mode for the SD Card.
  - Initialize SD Card.
    - If initialization fails, pause for a short amount of time and retry X times.
    - If initialization fails Y times, power cycle SD Card and try again.
- Read device `ID` from configuration.
  - If not set, generate a random number and set `ID` to `IOG3_<number>`.
- Start Wifi
- Start MQTT worker
- Start I2C worker
- Start Wiegand worker
- Start Alarm worker

## Rendering of the PCB

(sorry, no 3D models for some components)

## Configuration file examples

`alarm.jsn`

```json
{
	"sensors":	{
		"digital":	{
			"input":	{
				"0":	{
					"name":	"D0",
					"enabled":	true,
					"armed_state":	true,
					"entry_delay":	5,
					"exit_delay":	5
				},
				"1":	{
					"name":	"1",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"2":	{
					"name":	"2",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"3":	{
					"name":	"3",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"4":	{
					"name":	"4",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"5":	{
					"name":	"5",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"6":	{
					"name":	"6",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				},
				"7":	{
					"name":	"7",
					"enabled":	false,
					"armed_state":	true,
					"entry_delay":	0,
					"exit_delay":	0
				}
			},
			"output":	{
				"0":	{
					"name":	"0",
					"allow_external_control":	true
				},
				"1":	{
					"name":	"1",
					"allow_external_control":	true
				},
				"2":	{
					"name":	"2",
					"allow_external_control":	true
				},
				"3":	{
					"name":	"3",
					"allow_external_control":	true
				},
				"4":	{
					"name":	"4",
					"allow_external_control":	true
				},
				"5":	{
					"name":	"5",
					"allow_external_control":	true
				},
				"6":	{
					"name":	"6",
					"allow_external_control":	true
				},
				"7":	{
					"name":	"7",
					"allow_external_control":	true
				}
			}
		},
		"analog":	{
			"input":	{
				"0":	{
					"name":	"0",
					"enabled":	true,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"1":	{
					"name":	"1",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"2":	{
					"name":	"2",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"3":	{
					"name":	"3",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"4":	{
					"name":	"4",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"5":	{
					"name":	"5",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"6":	{
					"name":	"6",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				},
				"7":	{
					"name":	"7",
					"enabled":	false,
					"allowed_range":	{
						"min":	10000,
						"max":	14000
					},
					"entry_delay":	0,
					"exit_delay":	0
				}
			}
		}
	},
	"section":	[{
			"name":	"all",
			"digital":	[7],
			"analog":	[7]
		}],
	"codes":	[{
			"user":	"Default user",
			"verification_data":	"$argon2i$v=19$m=8,t=8,p=1$qoM58bCkv0Pqu4P+USzH2g$iIjDNYha1Ab0H1o+wSv7xXZted1obgT7GGxm6XM5tVw"
		}],
	"timing":	{
		"timeout":	{
			"triggered":	60,
			"silence":	60
		}
	}
}
```

`dev_id.jsn`

```json
{
	"device_id":	"g3"
}
```

`mqtt.jsn`

```json
{
	"keep_alive_seconds":	15,
	"broker":	{
		"address":	"1.2.3.4",
		"port":	1883
	}
}
```

`notes.jsn`

```json
{
	"entry_delay": {
		"signal": [500, 500],
		"repeat": true
	},
	"exit_delay": {
		"signal": [1500, 500],
		"repeat": true
	},
	"error": {
		"signal": [250, 250, 250, 250, 250],
		"repeat": false
	},
	"armed": {
		"signal": [800, 200, 800, 200, 800],
		"repeat": false
	},
	"disarmed": {
		"signal": [800, 200, 800, 200],
		"repeat": false
	},
	"key_entry_timeout": {
		"signal": [200, 200, 200, 200, 200, 200],
		"repeat": false
	}
}
```

`sntp.jsn`

```
{
	"sntp_servers":	["0.se.pool.ntp.org", "1.se.pool.ntp.org", "2.se.pool.ntp.org"]
}
```

`wifi.jsn`

```json
{
	"ssid":	"Your SSID",
	"password":	"Your password"
}
```

## KiCad design hardware/G3.kicad_pcb

Parts:
LOGO101: Logo_Open_Hardware_Small; OSHW-Logo2_7.3x6mm_SilkScreen
MH101, MH102, MH103, MH104: MountingHole; MountingHole_4.3mm_M4

Parts:
C201, C202, C203, C204: 100n; C_0805_2012Metric
C205, C206: 100u; CP_Radial_D6.3mm_P2.50mm
D201, D206, D207: Red; LED_D5.0mm
D202, D203: RBR3MM30ATR; D_SOD-123F
D204: 3.3V; D_SOD-123
D205: 5.1V; D_SOD-123
F201, F202, F203: xA; Fuseholder_TR5_Littlefuse_No560_No460
FL201: EMI_Filter_LCL; PinHeader_1x03_P2.54mm_Vertical
J202, J203: GS2; PinHeader_1x02_P2.54mm_Vertical
R201: 6.04k; R_0805_2012Metric
R202: 1.65k; R_0805_2012Metric
R203: 2.55k; R_0805_2012Metric
U201: LM1084-3.3; TO-263-3_TabPin2
U202: LM1084-5.0; TO-263-3_TabPin2

Connections:
12V_PWR: D202.2 (A), D203.2 (A), FL201.3, R201.2; also elsewhere on the board
+5V: C204.1, C206.1, D205.1 (K), F203.1, R203.2; also elsewhere on the board
/Power/3.3V_PWR: J202.2, U201.2 (VO)
/Power/3.3V_PWR_after_switch: F202.2, J202.1
/Power/5V_PWR: J203.2, U202.2 (VO)
/Power/5V_PWR_after_switch: F203.2, J203.1
/Power/12V_In1: C201.1, D202.1 (K), U201.3 (VI)
/Power/12V_In2: C202.1, D203.1 (K), U202.3 (VI)
/Power/12V_Source: F201.1, FL201.1
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, D201.1 (K), D204.2 (A), D205.2 (A), D206.1 (K), D207.1 (K), FL201.2, U201.1 (GND), U202.1 (GND); also elsewhere on the board
unnamed: D201.2 (A), R201.1
unnamed: D206.2 (A), R202.1
unnamed: D207.2 (A), R203.1
POWER_SUPPLY_12V: F201.2; also elsewhere on the board

Notes on the sheet:
Max 5A / 16.5 W
Max 5A / 25W
3.5A / 41.5W

Parts:
C301, C302, C304, C305, C306, C307, C308, C309, C310: 100n; C_0805_2012Metric
C303: 22u; C_0805_2012Metric
J301: Debug; PinHeader_2x05_P2.54mm_Vertical
J302: BME280; PinHeader_1x04_P2.54mm_Vertical
R301, R302, R303, R304, R305, R306, R307: 10k; R_0805_2012Metric
SW301: Boot option; SW_SPST_CK_KXT3
SW302: Reset; SW_SPST_CK_KXT3
SW303: Factory reset; SW_SPST_CK_KXT3
U301: ESP32_WROVER
U302: SN74LV4T125; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/MCU/CH_Enable: C301.1, C302.2, J301.3, R301.2, SW302.2, U301.3 (EN)
/MCU/Factory_reset: R302.2, SW303.1, U301.6 (GPI34)
/MCU/RDX: J301.7, U301.35 (TDX0/GPIO1)
/MCU/TDX: J301.5, U301.34 (RXD0/GPIO3)
ANALOG_RDY_1: U301.5 (GPI39/SENSOR_VN); also elsewhere on the board
ANALOG_RDY_2: U301.4 (GPI36/SENSOR_VP); also elsewhere on the board
Boot_option: C307.1, J301.2, R304.2, SW301.2, U301.25 (GPIO0/Boot_option); also elsewhere on the board
DIA_Interrupt: R307.2, U301.7 (GPI35); also elsewhere on the board
EXTERNAL_SIREN_CTRL: U301.37 (GPIO23); also elsewhere on the board
GND: C301.2, C302.1, C303.2, C304.1, C305.1, C306.1, C307.2, C308.2, C309.1, C310.1, J301.1, J302.2, SW301.1, SW302.1, SW303.2, U301.1 (GND), U301.15 (GND), U301.38 (GND), U301.39 (GND), U302.1 (~OE1), U302.4 (~OE2), U302.7 (GND), U302.9 (3A), U302.12 (4A); also elsewhere on the board
I2C_Reset: R306.2, U301.10 (GPIO25); also elsewhere on the board
I2C_SCL: J302.3, R303.2, U301.9 (GPIO33); also elsewhere on the board
I2C_SDA: J302.4, R305.2, U301.8 (GPIO32); also elsewhere on the board
unnamed: C306.2, U301.11 (GPIO26), U302.6 (2Y)
unnamed: C308.1, U301.12 (GPIO27), U302.3 (1Y)
SD_CD: U301.33 (GPIO21); also elsewhere on the board
SD_CLK: J301.10, U301.13 (MTMS/GPIO14); also elsewhere on the board
SD_CMD: J301.8, U301.23 (MTDO/GPIO15/LogPrint_option); also elsewhere on the board
SD_DATA0: U301.24 (GPIO2); also elsewhere on the board
SD_DATA1: U301.26 (GPIO4); also elsewhere on the board
SD_DATA2: J301.6, U301.14 (MTDI/GPIO12); also elsewhere on the board
SD_DATA3: J301.4, U301.16 (MTCK/GPIO13); also elsewhere on the board
SD_SPI_CLK: U301.30 (GPIO18); also elsewhere on the board
SD_SPI_CS: U301.29 (GPIO5); also elsewhere on the board
SD_SPI_MISO: U301.31 (GPIO19); also elsewhere on the board
SD_SPI_MOSI: U301.36 (GPIO22); also elsewhere on the board
Wiegand_D0: C309.2, U302.2 (1A); also elsewhere on the board
Wiegand_D1: C310.2, U302.5 (2A); also elsewhere on the board

Notes on the sheet:
Note: RX<->TX
Near Wrover module
Pin layout according to ESP32-Wrover-kit-debug-breakout

Parts:
C501, C502: 100n; C_0805_2012Metric
R501, R502: 10k; R_0805_2012Metric
U501, U502: ADS1115IDGST; TSSOP-10_3x3mm_P0.5mm

Connections:
/AnalogInput/AnalogSensCircuit1/Adc: U501.4 (AIN0); also elsewhere on the board
/AnalogInput/AnalogSensCircuit2/Adc: U501.5 (AIN1); also elsewhere on the board
/AnalogInput/AnalogSensCircuit3/Adc: U501.6 (AIN2); also elsewhere on the board
/AnalogInput/AnalogSensCircuit4/Adc: U501.7 (AIN3); also elsewhere on the board
/AnalogInput/AnalogSensCircuit5/Adc: U502.4 (AIN0); also elsewhere on the board
/AnalogInput/AnalogSensCircuit6/Adc: U502.5 (AIN1); also elsewhere on the board
/AnalogInput/AnalogSensCircuit7/Adc: U502.6 (AIN2); also elsewhere on the board
/AnalogInput/AnalogSensCircuit8/Adc: U502.7 (AIN3); also elsewhere on the board
ANALOG_RDY_1: R502.2, U501.2 (ALERT/RDY); also elsewhere on the board
ANALOG_RDY_2: R501.2, U502.2 (ALERT/RDY); also elsewhere on the board
GND: C501.2, C502.2, U501.1 (ADDR), U501.3 (GND), U502.3 (GND); also elsewhere on the board
I2C_SCL: U501.10 (SCL), U502.10 (SCL); also elsewhere on the board
I2C_SDA: U501.9 (SDA), U502.9 (SDA); also elsewhere on the board

Notes on the sheet:
I2C address: 0x49
Near ADS1115:2
Near ADS1115:1
I2C address: 0x48

Parts:
BZ1401: SDC1610M5-01; SDC1610M5-01_Buzzer_16diam_5pitch
C1401, C1402: 100n; C_0805_2012Metric
D1401: SDCard Init OK; LED_D5.0mm
D1402, D1403, D1405, D1406, D1408, D1409, D1411, D1412: Red; LED_D5.0mm
D1404: Wifi Connected; LED_D5.0mm
D1407: SNTP Time set; LED_D5.0mm
D1410: MQTT Connected; LED_D5.0mm
R1401, R1402, R1403, R1404, R1405, R1406, R1407, R1408, R1409, R1410, R1411, R1412: 1.65k; R_0805_2012Metric
U1401, U1402: MCP23017; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
/DigitalIO/Internal siren/Output: BZ1401.1 (-); also elsewhere on the board
BELL_CTRL: U1402.1 (GPB0); also elsewhere on the board
DI1: U1401.21 (GPA0); also elsewhere on the board
DI2: U1401.22 (GPA1); also elsewhere on the board
DI3: U1401.23 (GPA2); also elsewhere on the board
DI4: U1401.24 (GPA3); also elsewhere on the board
DI5: U1401.25 (GPA4); also elsewhere on the board
DI6: U1401.26 (GPA5); also elsewhere on the board
DI7: U1401.27 (GPA6); also elsewhere on the board
DI8: U1401.28 (GPA7); also elsewhere on the board
DIA_Interrupt: U1401.20 (INTA); also elsewhere on the board
DO1: U1401.1 (GPB0); also elsewhere on the board
DO2: U1401.2 (GPB1); also elsewhere on the board
DO3: U1401.3 (GPB2); also elsewhere on the board
DO4: U1401.4 (GPB3); also elsewhere on the board
DO5: U1401.5 (GPB4); also elsewhere on the board
DO6: U1401.6 (GPB5); also elsewhere on the board
DO7: U1401.7 (GPB6); also elsewhere on the board
DO8: U1401.8 (GPB7); also elsewhere on the board
GND: BZ1401.2 (+), C1401.2, C1402.2, D1401.1 (K), D1402.1 (K), D1403.1 (K), D1404.1 (K), D1405.1 (K), D1406.1 (K), D1407.1 (K), D1408.1 (K), D1409.1 (K), D1410.1 (K), D1411.1 (K), D1412.1 (K), U1401.10 (GND), U1401.15 (A0), U1401.16 (A1), U1401.17 (A2), U1402.10 (GND), U1402.16 (A1), U1402.17 (A2); also elsewhere on the board
I2C_Reset: U1401.18 (~RESET), U1402.18 (~RESET); also elsewhere on the board
I2C_SCL: U1401.12 (SCL), U1402.12 (SCL); also elsewhere on the board
I2C_SDA: U1401.13 (SDA), U1402.13 (SDA); also elsewhere on the board
INTERNAL_SIREN_CTRL: U1402.2 (GPB1); also elsewhere on the board
unnamed: D1401.2 (A), R1401.1
unnamed: D1402.2 (A), R1402.1
unnamed: D1403.2 (A), R1403.1
unnamed: D1404.2 (A), R1404.1
unnamed: D1405.2 (A), R1405.1
unnamed: D1406.2 (A), R1406.1
unnamed: D1407.2 (A), R1407.1
unnamed: D1408.2 (A), R1408.1
unnamed: D1409.2 (A), R1409.1
unnamed: D1410.2 (A), R1410.1
unnamed: D1411.2 (A), R1411.1
unnamed: D1412.2 (A), R1412.1
unnamed: R1401.2, U1402.4 (GPB3)
unnamed: R1402.2, U1402.5 (GPB4)
unnamed: R1403.2, U1402.6 (GPB5)
unnamed: R1404.2, U1402.7 (GPB6)
unnamed: R1405.2, U1402.8 (GPB7)
unnamed: R1406.2, U1402.21 (GPA0)
unnamed: R1407.2, U1402.22 (GPA1)
unnamed: R1408.2, U1402.23 (GPA2)
unnamed: R1409.2, U1402.24 (GPA3)
unnamed: R1410.2, U1402.25 (GPA4)
unnamed: R1411.2, U1402.26 (GPA5)
unnamed: R1412.2, U1402.27 (GPA6)
SD_CARD_PWR_CTRL: U1402.3 (GPB2); also elsewhere on the board
SD_MODE: U1402.28 (GPA7); also elsewhere on the board

Notes on the sheet:
Adress 0x20
Near MCP23017
Adress 0x21
"Status" device
"Input output" device

Parts:
F3501, F3502, F3503, F3504, F3505, F3506: xA; Fuseholder_TR5_Littlefuse_No560_No460
J3501, J3503: Sense; MOLEX_1x9_39544-3009
J3502: Digital Input; MOLEX_1x9_39544-3009
J3504, J3506: Digital input; MOLEX_1x9_39544-3009
J3505: Power 12/5/3; MOLEX_1x9_39544-3009
J3507: Digital Output; MOLEX_1x9_39544-3009
J3508, J3509: Digital output; MOLEX_1x9_39544-3009

Connections:
12V_PWR: F3501.2, F3502.2; also elsewhere on the board
+5V: F3503.2, F3504.2; also elsewhere on the board
BELL_PWR: J3508.9, J3509.2; also elsewhere on the board
DI1_1: J3502.2; also elsewhere on the board
DI1_2: J3502.3; also elsewhere on the board
DI1_PWR: J3502.1; also elsewhere on the board
DI2_1: J3502.5; also elsewhere on the board
DI2_2: J3502.6; also elsewhere on the board
DI2_PWR: J3502.4; also elsewhere on the board
DI3_1: J3502.8; also elsewhere on the board
DI3_2: J3502.9; also elsewhere on the board
DI3_PWR: J3502.7; also elsewhere on the board
DI4_1: J3504.2; also elsewhere on the board
DI4_2: J3504.3; also elsewhere on the board
DI4_PWR: J3504.1; also elsewhere on the board
DI5_1: J3504.5; also elsewhere on the board
DI5_2: J3504.6; also elsewhere on the board
DI5_PWR: J3504.4; also elsewhere on the board
DI6_1: J3504.8; also elsewhere on the board
DI6_2: J3504.9; also elsewhere on the board
DI6_PWR: J3504.7; also elsewhere on the board
DI7_1: J3506.2; also elsewhere on the board
DI7_2: J3506.3; also elsewhere on the board
DI7_PWR: J3506.1; also elsewhere on the board
DI8_1: J3506.5; also elsewhere on the board
DI8_2: J3506.6; also elsewhere on the board
DI8_PWR: J3506.4; also elsewhere on the board
DO1_PWR: J3507.2; also elsewhere on the board
DO2_PWR: J3507.4; also elsewhere on the board
DO3_PWR: J3507.6; also elsewhere on the board
DO4_PWR: J3507.8; also elsewhere on the board
DO5_PWR: J3508.1; also elsewhere on the board
DO6_PWR: J3508.3; also elsewhere on the board
DO7_PWR: J3508.5; also elsewhere on the board
DO8_PWR: J3508.7; also elsewhere on the board
GND: J3501.1, J3501.3, J3501.5, J3501.7, J3501.9, J3503.2, J3503.4, J3503.6, J3505.1, J3505.3, J3506.7, J3507.1, J3507.3, J3507.5, J3507.7, J3507.9, J3508.2, J3508.4, J3508.6, J3508.8, J3509.1, J3509.3, J3509.5, J3509.7, J3509.8, J3509.9; also elsewhere on the board
unnamed: F3501.1, J3505.4
unnamed: F3502.1, J3505.5
unnamed: F3503.1, J3505.6
unnamed: F3504.1, J3505.7
unnamed: F3505.1, J3505.8
unnamed: F3506.1, J3505.9
POWER_SUPPLY_12V: J3505.2; also elsewhere on the board
SIREN_PWR: J3509.4, J3509.6; also elsewhere on the board
Sense1_DUT: J3501.2; also elsewhere on the board
Sense2_DUT: J3501.4; also elsewhere on the board
Sense3_DUT: J3501.6; also elsewhere on the board
Sense4_DUT: J3501.8; also elsewhere on the board
Sense5_DUT: J3503.1; also elsewhere on the board
Sense6_DUT: J3503.3; also elsewhere on the board
Sense7_DUT: J3503.5; also elsewhere on the board
Sense8_DUT: J3503.7; also elsewhere on the board
Wiegand_D0: J3506.8; also elsewhere on the board
Wiegand_D1: J3506.9; also elsewhere on the board

Notes on the sheet:
Analog sensors sense voltage level based on resistance between SenseN_DUT and GND

Parts:
C401, C403: 100n; C_0805_2012Metric
C402: 10u; CP_Elec_5x4.5
D401: Red; LED_D5.0mm
D402, D403, D404, D405, D406, D407: D_TVS; D_0603_1608Metric
J401: Micro_SD_Card_Det; microSD_HC_Hirose_DM3AT-SF-PEJM5
Q401: ZXTN25050DFHTA; SOT-23
R401, R402, R403, R404, R405, R406: 50k; R_0805_2012Metric
R407, R409, R411: 10k; R_0805_2012Metric
R408: 1.65k; R_0805_2012Metric
R410: 470; R_0805_2012Metric
SW1: SD SPI/MMC mode; SW_DIP_SPSTx02_Slide_Omron_A6S-210x_W8.9mm_P2.54mm
U401: MAX4948; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias

Connections:
/MCU/SDCard/SD_MMC_CLK: D404.1 (A1), J401.5 (CLK), R403.2, U401.16 (COM2)
/MCU/SDCard/SD_MMC_CMD: D405.1 (A1), J401.3 (CMD), R404.2, U401.23 (COM6)
/MCU/SDCard/SD_MMC_DATA0: D403.1 (A1), J401.7 (DAT0), R402.2, U401.3 (COM5)
/MCU/SDCard/SD_MMC_DATA1: D402.1 (A1), J401.8 (DAT1), R401.2, U401.20 (COM1)
/MCU/SDCard/SD_MMC_Data2: D407.1 (A1), J401.1 (DAT2), U401.7 (COM4)
/MCU/SDCard/SD_MMC_Data3: D406.1 (A1), J401.2 (DAT3/CD), R405.2, U401.11 (COM3)
Boot_option: SW1.4; also elsewhere on the board
GND: C401.1, C402.2, C403.1, D401.1 (K), D402.2 (A2), D403.2 (A2), D404.2 (A2), D405.2 (A2), D406.2 (A2), D407.2 (A2), J401.6 (VSS), J401.11 (SHIELD), Q401.3 (E), R407.2, R411.1, U401.5 (~EN), U401.6 (GND), U401.21 (GND), U401.25 (EP/GND); also elsewhere on the board
unnamed: D401.2 (A), R408.1
unnamed: Q401.1 (B), R410.1, R411.2
SD_CARD_PWR: J401.9 (DET_B), Q401.2 (C)
SD_CARD_PWR_CTRL: R410.2; also elsewhere on the board
SD_CD: J401.10 (DET_A), R409.2; also elsewhere on the board
SD_CLK: U401.15 (NC2); also elsewhere on the board
SD_CMD: U401.1 (NC6); also elsewhere on the board
SD_DATA0: SW1.1, U401.4 (NC5); also elsewhere on the board
SD_DATA1: U401.18 (NC1); also elsewhere on the board
SD_DATA2: R406.2, U401.9 (NC4); also elsewhere on the board
SD_DATA3: U401.12 (NC3); also elsewhere on the board
SD_MODE: R407.1, R408.2, SW1.3, U401.14 (CB); also elsewhere on the board
SD_SPI_CLK: U401.17 (NO2); also elsewhere on the board
SD_SPI_CS: U401.10 (NO3); also elsewhere on the board
SD_SPI_MISO: U401.2 (NO5); also elsewhere on the board
SD_SPI_MOSI: U401.24 (NO6); also elsewhere on the board

Notes on the sheet:
Card present = SD_CD low
Place near SD Card
Place card slot as near the MCU as possible. Leave room to insert the card.
http://www.interfacebus.com/MicroSD_Card_Pinout.html
SPI signals
MMC Signals
Both On = SPI mode and JTAG support. GPIO2 needs to be LOW during boot to enter download mode; shorting it to GPIO0 (SD_DATA0) will allow this to happen.
Place near MAX4948
https://www.acmesystems.it/pcb_microsd
SD Pullups: R406 is placed on other side of MAX4948 to comply with ESP32 Wrover GPIO12 strapping pin for flash voltage (1.8V) selection regardless of SPI or MMC mode. Wrover-B uses 3.3V so don't populate R406 and call gpio_pullup_en(GPIO_NUM_12) after boot to allow SD Card operation.
